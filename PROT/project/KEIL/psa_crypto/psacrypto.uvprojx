# Keil uVision project psacrypto.uvprojx, settings and files
target psacrypto_lib (6090000::V6.9::.\ARMCLANG)
  device: ARMCM33_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") TZ CLOCK(12000000) ESEL ELITTLE
  output: psacrypto (library)
  AfterMake: cmd /c copy .\Objects\psacrypto.lib ..\secure_main\
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fshort-wchar
  c include: ..\..\..\mbedcrypto\tfm_crypto_include\mbedcrypto;..\..\..\trusted-firmware-m\secure_fw\partitions\crypto;..\..\..\trusted-firmware-m\platform\ext\common;..\..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include;..\..\..\..\ROM-EXPORT\source;..\..\..\..\ROM-EXPORT\platform;..\..\..\trusted-firmware-m\interface\include;..\..\..\mbedcrypto\library
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group psacrypto
    ../../../mbedcrypto/library/: psa_crypto.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c
