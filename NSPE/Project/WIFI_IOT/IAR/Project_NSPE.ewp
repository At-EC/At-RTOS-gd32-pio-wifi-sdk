# IAR project Project_NSPE.ewp, settings and files
configuration Freertos (ARM)
  General.OGChipSelectEditMenu: GD32W515xI GD GD32W515xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: PLATFORM_OS_FREERTOS; CONFIG_TZ_ENABLED
  ICCARM.CCDiagSuppress: Pa050,Pe223,Pe177,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\Firmware\CMSIS\DSP_Lib_v1.6.0\include; ..\..\..\Firmware\CMSIS\GD\GD32W51x\Include; ..\..\..\Firmware\GD32W51x_standard_peripheral\Include; ..\..\..\Firmware\GD32W51x_wifi_driver\inc; ..\..\..\Firmware\GD32W51x_wifi_driver\osal; ..\..\..\Firmware\GD32W51x_wifi_driver\cmn; ..\..\..\Firmware\GD32W51x_wifi_driver\soc; ..\..\..\WIFI_IOT\app; ..\..\..\WIFI_IOT\bsp; ..\..\..\WIFI_IOT\common; ..\..\..\WIFI_IOT\wifi; ..\..\..\WIFI_IOT\os; ..\..\..\WIFI_IOT\os\FreeRTOSv10.3.1\Source\include; ..\..\..\WIFI_IOT\os\FreeRTOSv10.3.1\Source\portable\IAR\ARM_CM33_NTZ; ..\..\..\WIFI_IOT\network\lwip-2.1.2\apps; ..\..\..\WIFI_IOT\network\lwip-2.1.2\port; ..\..\..\WIFI_IOT\network\lwip-2.1.2\src\include; ..\..\..\WIFI_IOT\network\lwip-2.1.2\src\include\lwip; ..\..\..\WIFI_IOT\network\lwip-2.1.2\port\arch; ..\..\..\WIFI_IOT\network\mbedtls-2.17.0-ssl\include; ..\..\..\WIFI_IOT\network\mbedtls-2.17.0-ssl\ns_interface; ..\..\..\WIFI_IOT\network\iperf3; ..\..\..\WIFI_IOT\cloud\alicloud; ..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\infra; ..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\dev_model; ..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wrappers; ..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng; ..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src; ..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision; ..\..\..\WIFI_IOT\fatfs; ..\..\..\WIFI_IOT\fatfs\src; ..\..\..\..\config; ..\..\..\..\ROM-EXPORT\source; ..\..\..\..\ROM-EXPORT\platform; ..\..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include; ..\..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include\mbedtls; ..\..\..\..\MBL\platform; ..\..\..\..\MBL\source; ..\..\..\..\MBL\source_ns; ..\..\..\..\PROT\trusted-firmware-m\interface\include; ..\..\..\..\PROT\mbedtls_ns_callable; ..\..\..\WIFI_IOT\os\FreeRTOSv10.3.1\CMSIS\RTOS2\FreeRTOS\Include; ..\..\..\WIFI_IOT\os\FreeRTOSv10.3.1\CMSIS\RTOS2\FreeRTOS\Source; $TOOLKIT_DIR$\CMSIS\Core\Include; ..\..\..\WIFI_IOT\app\mqtt_app
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\..\..\WIFI_IOT\app
  OBJCOPY.OOCOutputFile: Project_NSPE.srec
  prebuild: nspe_prebuild.bat TZ $PROJ_DIR$ "$TOOLKIT_DIR$"
  postbuild: ..\nspe_afterbuild_tz.bat TZ SIP "" DAPLINK $TARGET_DIR$ IAR "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: nspe.axf
  ILINK.IlinkIcfFile: nspe.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../WIFI_IOT/app/: cmd_shell.c console.c main.c
  group Application/Alicloud
    ../../../WIFI_IOT/lib/IAR/: alicloud.a
    ../../../WIFI_IOT/cloud/alicloud/: alicloud_entry.c linkkit_example_solo.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/infra/: infra_aes.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wrappers/: wrappers.c
  group Armdsp
    ../../../Firmware/CMSIS/DSP_Lib_v1.6.0/source/: arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix2_f32.c arm_cfft_radix4_f32.c arm_cfft_radix8_f32.c arm_common_tables.c arm_const_structs.c arm_cos_f32.c arm_sin_cos_f32.c arm_sin_f32.c
  group Bsp
    ../../../WIFI_IOT/bsp/: bsp_wlan.c dma.c gd32_it.c init_rom.c rf_efuse.c trng.c uart.c
  group Common
    ../../../WIFI_IOT/common/: cJSON.c debug_print.c delay.c dlist.c malloc.c wakelock.c wrapper_os.c
  group Demo
    ../../../WIFI_IOT/demo/: iperf3_main.c ota_demo.c ssl_client.c tcp_test.c udp_test.c
    ../../../WIFI_IOT/app/mqtt_app/: mqtt5_client_config.c mqtt_client_config.c mqtt_cmd.c
  group Fatfs
    ../../../WIFI_IOT/FatFS/src/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../WIFI_IOT/FatFS/: fatfs.c wear_levelling_flash.c
  group Freertos
    ../../../WIFI_IOT/os/FreeRTOSv10.3.1/CMSIS/RTOS2/FreeRTOS/Source/ARM/: clib_arm.c
    ../../../WIFI_IOT/os/FreeRTOSv10.3.1/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c freertos_evr.c os_systick.c
    ../../../WIFI_IOT/os/FreeRTOSv10.3.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../WIFI_IOT/os/FreeRTOSv10.3.1/Source/portable/IAR/ARM_CM33_NTZ/: port.c portasm.s portasm1.s
    ../../../WIFI_IOT/os/FreeRTOSv10.3.1/Source/portable/Common/: tickless_sleep.c
  group Library
    ../../../WIFI_IOT/lib/IAR/: iperf3.a mbedtls_s_veneers.o mbl_cmse_Lib.o wlanlib.a
  group Lwip
    ../../../WIFI_IOT/network/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../WIFI_IOT/network/lwip-2.1.2/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c
    ../../../WIFI_IOT/network/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../WIFI_IOT/network/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../WIFI_IOT/network/lwip-2.1.2/port/: dhcpd.c ethernetif.c sys_arch.c wifi_netif.c
    ../../../WIFI_IOT/network/lwip-2.1.2/src/netif/: ethernet.c
    ../../../WIFI_IOT/network/lwip-2.1.2/apps/mqtt/: mqtt.c mqtt5.c mqtt_ssl_config.c
    ../../../WIFI_IOT/network/lwip-2.1.2/apps/ping/: ping.c
  group Mbedtls
    ../../../WIFI_IOT/network/mbedtls-2.17.0-ssl/library/: debug.c net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_default_conf.c ssl_self_test.c ssl_srv.c ssl_ticket.c ssl_tls.c
    ../../../WIFI_IOT/network/mbedtls-2.17.0-ssl/ns_interface/: mbedtls_ns_function_api.c ns_interface.c
    ../../../../PROT/trusted-firmware-m/interface/src/: tfm_crypto_func_api.c
  group Peripherals
    ../../../Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_adc.c gd32w51x_cau.c gd32w51x_cau_aes.c gd32w51x_cau_des.c gd32w51x_cau_tdes.c gd32w51x_crc.c gd32w51x_dbg.c gd32w51x_dci.c gd32w51x_dma.c gd32w51x_efuse.c gd32w51x_exti.c gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_hau.c gd32w51x_hau_sha_md5.c gd32w51x_hpdf.c gd32w51x_i2c.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_pkcau.c gd32w51x_pmu.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_rtc.c gd32w51x_sdio.c gd32w51x_spi.c gd32w51x_sqpi.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_trng.c gd32w51x_tsi.c gd32w51x_tzpcu.c gd32w51x_usart.c gd32w51x_wwdgt.c
  group Peripherals/Cmsis
    ../../../Firmware/CMSIS/GD/GD32W51x/Source/IAR/: startup_gd32w51x.s
    ../../../Firmware/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
  group Wifi
    ../../../WIFI_IOT/wifi/: wifi_eloop.c wifi_management.c wifi_netlink.c
