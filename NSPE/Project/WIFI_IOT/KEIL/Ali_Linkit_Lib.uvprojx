# Keil uVision project Ali_Linkit_Lib.uvprojx, settings and files
target ali_linkit_sdk (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: alicloud (library)
  AfterMake: cmd /c copy .\alicloud\alicloud.lib ..\..\..\WIFI_IOT\lib\KEIL\
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=1295 --diag_suppress=111
  c include: ..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\coap_server;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\dev_model;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\dev_sign;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\coap_server\CoAPPacket;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\infra;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\mqtt;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\ota;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\frameworks;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\frameworks\aplist;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\frameworks\ieee80211;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\frameworks\statics;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\frameworks\utils;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wrappers;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\connectivity;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\p2p;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\phone_ap;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\zero_config;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\smartconfig;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\dev_ap;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision\mcast_smartconfig;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\coap_server\server;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\dev_bind;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\ota
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group certs
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/certs/: root_ca.c
  group coap_server
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/coap_server/server/: CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPObserve.c CoAPPlatform.c CoAPResource.c CoAPServer.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/coap_server/CoAPPacket/: CoAPDeserialize_common.c CoAPMessage_common.c CoAPSerialize_common.c
  group dev_sign
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/dev_sign/: dev_sign_mqtt.c
  group dev_model
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/dev_model/: dm_api.c dm_client.c dm_client_adapter.c dm_cota.c dm_fota.c dm_ipc.c dm_log_report.c dm_manager.c dm_message.c dm_message_cache.c dm_msg_process.c dm_opt.c dm_ota.c dm_server.c dm_server_adapter.c dm_shadow.c dm_tsl_alink.c dm_utils.c impl_gateway.c impl_linkkit.c impl_ntp.c impl_solo.c iotx_cm.c iotx_cm_coap.c iotx_cm_mqtt.c
  group dev_bind
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/dev_bind/: bind.c bind_coap.c bind_mqtt.c bind_msg.c bind_token.c bind_utils.c
  group infra
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/infra/: infra_cjson.c infra_compat.c infra_defs.c infra_json_parser.c infra_log.c infra_md5.c infra_net.c infra_report.c infra_sha1.c infra_sha256.c infra_string.c infra_timer.c infra_httpc.c
  group mqtt
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/mqtt/: iotx_mqtt_client.c mqtt_api.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group ota
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/ota/: iotx_ota.c ota_coap.c ota_fetch.c ota_lib.c ota_mqtt.c
  group wifi_provision
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/frameworks/: awss.c awss_main.c zconfig_protocol.c zconfig_vendor_common.c awss_discover.c connect_ap.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/frameworks/utils/: awss_crypt.c zconfig_utils.c awss_event.c os_misc.c passwd.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/frameworks/ieee80211/: zconfig_ieee80211.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/frameworks/aplist/: awss_aplist.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/p2p/: awss_wps.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/smartconfig/: awss_smartconfig.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/zero_config/: awss_enrollee.c awss_registrar.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/connectivity/: wifi_mqtt.c wifi_coap.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/mcast_smartconfig/: mcast_smartconfig.c
    ../../../WIFI_IOT/cloud/alicloud/iotkit-embedded-3.2.0/lib_iot_sdk_src/eng/wifi_provision/dev_ap/: awss_dev_ap.c
